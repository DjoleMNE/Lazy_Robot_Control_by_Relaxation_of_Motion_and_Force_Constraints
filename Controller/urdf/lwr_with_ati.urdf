Commit message: {LWR RTT} ATI-Link 7 Frame rotated

File: Controller/urdf/lwr_with_ati.urdf (robot description, URDF)
Before this commit: robot lwr, 11 links, 10 joints
Joints:
- joint joint_6: origin xyz=0 0 0.1266 rpy=0 0 0 -> xyz=0 0 0.1266 rpy=0 0 0.349066
