Commit message: [YouBot constants] moved from mediator to separate hpp file

File: Controller/urdf/youbot_arm_zero_inertia.urdf (robot description, URDF)
Before this commit: robot youbot, 10 links, 9 joints
Links:
- link arm_link_5: mass 0.687 -> 0.807
