Commit message: [URDF] youBot mass parameters updated

File: Controller/urdf/youbot_arm_only.urdf (robot description, URDF)
Before this commit: robot youbot, 10 links, 9 joints
Links:
- link gripper_palm_link: mass 0.1 -> 0.199
